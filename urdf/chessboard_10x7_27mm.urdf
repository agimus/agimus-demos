Commit message: [urdf] Rename calibration_mire.

File: urdf/chessboard_10x7_27mm.urdf (robot description, URDF)
Before this commit: robot calibration_mire, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.297 0.21 0.001; visual box size=0.297 0.21 0.001
